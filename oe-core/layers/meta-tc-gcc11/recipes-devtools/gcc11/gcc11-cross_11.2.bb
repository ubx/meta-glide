require gcc-${PV}.inc
require gcc-cross.inc

PN = "gcc11-cross-${TUNE_PKGARCH}"
PROVIDES = "gcc11-cross"

