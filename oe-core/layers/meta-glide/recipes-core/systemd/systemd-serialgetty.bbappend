DESCRIPTION="Change linux console"

SERIAL_CONSOLE = "115200 ttyHS0"
