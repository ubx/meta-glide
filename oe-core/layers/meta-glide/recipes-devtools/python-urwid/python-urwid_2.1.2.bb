inherit setuptools
require python-urwid.inc

# Uncomment the lines below and add runtime dependencies if any. Our example does not have any dependencies.
#RDEPENDS_${PN} += ""
#RDEPENDS_${PN}_class-native = ""